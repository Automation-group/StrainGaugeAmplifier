# Repository Automation-group/StrainGaugeAmplifier

## KiCad design Power_supply/Power_supply.kicad_pcb

Parts:
C1, C2: 1000 мк 50 В; CAPACITOR_5.08_D13
C3, C4: 220 мк 25 В; CAPACITOR_3_D8
C5, C6: 0.1 мк; CAPACITOR_K10-17
DA1: LM7815; TO220_RAD_16.5x15
DA2: LM7915; TO220_RAD_16.5x15
TV1: TP-112-11; TP112-11
VD1, VD2, VD3, VD4: 1N5819; DO-41
X1: DG301-5.0-02P; DG126-5.0-02P-14
X2: DG301-5.0-03P; DG126-5.0-03P-14

Connections:
/+15V: C3.1, C5.1, DA1.3 (Vout), X2.3
/-15V: C4.2, C6.2, DA2.3 (Vout), X2.1
/GND: C1.2, C2.1, C3.2, C4.1, C5.2, C6.1, DA1.2 (com), DA2.1 (com), TV1.8, TV1.9, X2.2
unnamed: C1.1, DA1.1 (Vin), VD3.2, VD4.2
unnamed: C2.2, DA2.2 (Vin), VD1.1, VD2.1
unnamed: TV1.1, X1.2
unnamed: TV1.4, X1.1
unnamed: TV1.7, VD1.2, VD3.1
unnamed: TV1.10, VD2.2, VD4.1

Notes on the sheet:
~~220В 50Гц
Общий
+15В
-15В

Board: 2 copper layers, 115.0 x 50.0 mm, 19 parts (0 on the bottom side), 9 nets.

Other parts of the board:
1_PIN, 1_PIN#2, 1_PIN#3, 1_PIN#4: P***; 1_pin

## KiCad design StrainGaugeAmplifier/StrainGaugeAmplifier.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C7, C8, C9: 0.1 мк; CAPACITOR_K10-17
C6: 4.7 мк; CAPACITOR_K10-17
DA1: AD620; DIP_8
DA2, DA3: К544УД2Б; DIP_8
K1: BS-115C-12A-12VDC; BS-115C-12A
R1, R2: 10; RESISTOR_0.25W
R3: 39 к; RESISTOR_0.25W
R4, R5, R8: 5.1 к; RESISTOR_0.25W
R6, R9: 51 к; RESISTOR_0.25W
R7: 100; RESISTOR_0.25W
R10: 50 к; Electron_3296W
R11, R13, R15: 10 к; RESISTOR_0.25W
R12, R17: 10 к; Electron_3296W
R14: 100 к; RESISTOR_0.25W
R16: 33 к; RESISTOR_0.25W
VD1, VD2, VD3: 1N4007; DO-41
VT1: MMBT5551; TO-92L_Inline_Wide
X1: WF-4
X2: WF-5
X3: WF-6
X4: WF-3

Connections:
/+VCC: C1.1, C4.1, C8.1, DA1.7 (V+), DA2.7 (V+), DA3.7 (V+), R7.1, R11.1, X1.1, X2.3, X3.1, X3.4
/-VCC: C2.1, C5.1, C9.1, DA1.4 (V-), DA2.4 (V-), DA3.4 (V-), R13.2, X1.4
/GND: C1.2, C2.2, C4.2, C5.2, C8.2, C9.2, DA1.5 (REF), DA2.3, R6.2, R14.1, VT1.1, X1.2, X1.3, X2.4, X3.3, X3.6, X4.3
unnamed: C3.1, DA2.8
unnamed: C3.2, DA2.1
unnamed: C6.1, DA2.6, R10.2, R10.3, X4.2
unnamed: C6.2, DA3.3, R14.2
unnamed: C7.1, DA3.8
unnamed: C7.2, DA3.1
unnamed: DA1.1 (Rg), R3.2
unnamed: DA1.2, X2.1
unnamed: DA1.3, K1.3, R1.1, R2.1, X2.2
unnamed: DA1.6, R8.2
unnamed: DA1.8 (Rg), R3.1
unnamed: DA2.2, R8.1, R9.2
unnamed: DA3.2, R15.1, R16.2
unnamed: DA3.6, R17.2, R17.3, X4.1
unnamed: K1.1, R7.2, VD1.2
unnamed: K1.7, R1.2, R2.2, X2.5
unnamed: K1.8, VD1.1, VT1.3
unnamed: R4.1, R5.1, R6.1, VT1.2
unnamed: R4.2, VD2.2
unnamed: R5.2, VD3.2
unnamed: R9.1, R10.1
unnamed: R11.2, R12.1
unnamed: R12.2, R15.2
unnamed: R12.3, R13.1
unnamed: R16.1, R17.1
unnamed: VD2.1, X3.2
unnamed: VD3.1, X3.5

Notes on the sheet:
IN+
+VCC
GND
-VCC
RELEY_ON
IN-
Усил. 30
Усил. 100

Board: 2 copper layers, 140.0 x 50.0 mm, 44 parts (0 on the bottom side), 30 nets.

Other parts of the board:
1_PIN, 1_PIN#2, 1_PIN#3, 1_PIN#4, 1_PIN#5, 1_PIN#6: P***; 1_pin

## Commit log

2022-03-11 Добавил проект усилителя для полумостового тензодатчика.
2022-03-14 Расположил элементы на плате и повёл трассировку.
2022-03-14 Добавил схему источника питания.
2022-03-21 Отправил печатные платы в производство.
2022-04-26 Поправил ошибки в схеме и на печатной плате Power_supply.
